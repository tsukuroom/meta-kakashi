RDEPENDS_${PN}_append_libc-glibc = "\
	glibc-gconv-utf-16 \
"
