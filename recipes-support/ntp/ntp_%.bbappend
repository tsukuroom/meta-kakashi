FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URL += " \
	file://ntp.conf \
"
